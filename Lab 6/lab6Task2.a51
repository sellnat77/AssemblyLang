		ORG 0000H
		LJMP MAIN
		

DOUBLEB:
		DB 81H,42H,24H,18H,24H,42H,81H
MAIN:
		
		
	
LOOP:
		MOV R0,#06H
		MOV DPTR,#DOUBLEB
AGAIN:
		CLR A
		MOVC A,@A+DPTR
		MOV P1,A
		ACALL DELAY
		INC DPTR
		DJNZ R0,AGAIN
		SJMP LOOP
	
	
	
DELAY:	
		MOV R3,#0FH
DLY0: 	MOV R1, #0FFH
DLY1: 	MOV R2,#0FFH
DLY2:	DJNZ R2, DLY2
		DJNZ R1,DLY1
		DJNZ R3,DLY0
		RET	
		
	
		
		
	END